# Keil uVision project ISO-STM32.uvprojx, settings and files
target 测试函数 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ISO-STM32 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\User;..\..\User\APP;..\..\User\BSP;..\..\User\BSP\Key;..\..\User\BSP\led;..\..\User\BSP\usart;..\..\User\uC-CPU;..\..\User\uC-CPU\ARM-Cortex-M3\RealView;..\..\User\uC-LIB;..\..\User\uCOS-III\Source;..\..\User\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\User\BSP\List;..\..\User\BSP\cjson;..\..\User\BSP\malloc;..\..\User\BSP\Ethernet\Internet;..\..\User\BSP\Ethernet\W5500;..\..\User\BSP\I2C_EEPROM;..\..\User\BSP\spi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group DOC
    ../../Doc/: readme.txt
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group APP
    ../../User/APP/: app.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group BSP
    ../../User/BSP/: bsp.c bsp.h
    ../../User/BSP/led/: bsp_led.c
    ../../User/BSP/usart/: bsp_usart1.c
    ../../User/BSP/Key/: bsp_key.c bsp_key.h
    ../../User/BSP/List/: bsp_list.c bsp_list.h
    ../../User/BSP/cjson/: bsp_cjosn.c bsp_cjson.h cJSON.c cJSON.h
    ../../User/BSP/malloc/: malloc.c malloc.h
    ../../User/BSP/I2C_EEPROM/: bsp_I2C_EEPROM.c bsp_I2C_EEPROM.h bsp_I2C_GPIO.c bsp_I2C_GPIO.h
    ../../User/BSP/spi/: bsp_SPI.c bsp_SPI.h
  group uC/CPU
    ../../User/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../User/uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../User/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../User/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../../User/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/OS-III Port
    ../../User/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group W5500
    ../../User/BSP/Ethernet/W5500/: w5500_conf.c w5500_conf.h w5500.c w5500.h socket.c socket.h utility.c utility.h types.h
  group Internet
    ../../User/BSP/Ethernet/Internet/: tcp_demo.c tcp_demo.h
